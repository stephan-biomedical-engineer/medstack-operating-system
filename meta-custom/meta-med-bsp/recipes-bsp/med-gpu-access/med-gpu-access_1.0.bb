SUMMARY = "MedPlatform access rule for a GPU whose device node arrives root-only"
DESCRIPTION = "A udev rule that opens the proprietary GPU driver's device node to \
the video group. On the STM32MP257 the galcore module creates /dev/galcore as \
0600 root:root, the compositor runs unprivileged, and it dies about six seconds \
into every boot reporting ENOENT for a node that exists."
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/MIT;md5=0835ade698e0bcf8506ecda2f7b4f302"

S = "${WORKDIR}"

# Which node, and that it needs this at all, is a fact about one machine's GPU
# stack; conf/layer.conf installs this through MED_GPU_PACKAGES, so it travels
# with the driver and an image without the driver does not carry the rule.
PACKAGE_ARCH = "${MACHINE_ARCH}"

do_install() {
    install -d ${D}${nonarch_base_libdir}/udev/rules.d
    # Group video and not mode 0666: the compositor's user already belongs to
    # video - it is the group seatd serves - so the node opens for the one
    # consumer it has and not for every process on the device. Measured
    # 2026-08-27, BRINGUP_HMI_STM32MP2.md §3.
    #
    # The vendor's own images get the equivalent from a package this image does
    # not install: ST ships the module in one place and the step that makes it
    # usable in another, which is how MED_GPU_PACKAGES came to exist too.
    printf '%s\n' \
        "# ${SUMMARY}" \
        "# Generated by ${PN} for ${MACHINE}. See BRINGUP_HMI_STM32MP2.md §3." \
        'KERNEL=="galcore", GROUP="video", MODE="0660"' \
        > ${D}${nonarch_base_libdir}/udev/rules.d/70-med-gpu-access.rules
}

FILES:${PN} = "${nonarch_base_libdir}/udev/rules.d"
